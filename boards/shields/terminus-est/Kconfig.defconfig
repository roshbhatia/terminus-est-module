## boards/shields/terminus-est/Kconfig.defconfig
```kconfig
if SHIELD_TERMINUS_EST

config ZMK_KEYBOARD_NAME
    default "terminus-est"

endif
```
